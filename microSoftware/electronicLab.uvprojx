# Keil uVision project electronicLab.uvprojx, settings and files
target Target 1 (6090000::V6.9::.\ARMCLANG)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: electronicLab +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.4.0\CMSIS\RTOS2\Include;C:\Keil_v5\ARM\PACK\ARM\CMSIS-Driver_Validation\1.1.0\Boards\Keil\MCBSTM32F400\CMSIS_DV_API\RTE\Device\STM32F407IGHx;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.13.0\Drivers\STM32F4xx_HAL_Driver\Inc;C:\Keil_v5\ARM\PACK\Keil\STM32F0xx_DFP\2.0.0\Drivers\STM32F0xx_HAL_Driver\Inc;C:\Keil_v5\ARM\PACK\Keil\STM32F0xx_DFP\2.0.0\MDK\Boards\ST\STM32F030-Discovery\Blinky\RTE\Device\STM32F030R8Tx\STCubeGenerated\Inc;C:\Keil_v5\ARM\PACK\Keil\STM32F0xx_DFP\2.0.0\MDK\Boards\ST\STM32F030-Discovery\Blinky\RTE\Device\STM32F030R8Tx;C:\Keil_v5\ARM\PACK\Keil\MDK-Middleware\7.6.0\USB\Include;..\..\..\Blinky.tar\Blinky
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, Device:Startup 1.0.0, CMSIS Driver:SPI 1.0.0
